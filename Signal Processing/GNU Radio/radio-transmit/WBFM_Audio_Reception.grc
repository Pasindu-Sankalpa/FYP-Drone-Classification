options:
  parameters:
    generate_options: qt_gui
    id: WBFM_Audio_Reception
    output_language: python
    title: WBFM_Audio_Reception
  states: {}

blocks:
- name: audio_decim_1
  id: variable
  parameters:
    comment: |-
      Down-sample
      1.2M/5 = 240k
    value: '5'
  states: {}
- name: audio_decim_2
  id: variable
  parameters:
    comment: |-
      Down-sample
      240k/5 = 48k
    value: '5'
  states: {}
- name: rf_gain
  id: variable_qtgui_range
  parameters:
    comment: Adjust the RX gain
    start: '0'
    step: '1'
    stop: '70'
    value: '20'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 1.2e6
  states: {}
- name: tuning
  id: variable_qtgui_range
  parameters:
    comment: Tune the station
    start: 88e6
    step: 1e5
    stop: 108e6
    value: 90e6
  states: {}
- name: volume
  id: variable_qtgui_range
  parameters:
    comment: Change volume
    start: '0'
    step: '0.1'
    stop: '3'
    value: '0.6'
  states: {}
- name: analog_wfm_rcv_0
  id: analog_wfm_rcv
  parameters:
    audio_decimation: '1'
    quad_rate: 240e3
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: volume
    type: float
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 200e3
    decim: audio_decim_1
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: '1000'
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_1
  id: low_pass_filter
  parameters:
    cutoff_freq: 18e3
    decim: audio_decim_2
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_fff
    width: '1000'
    win: window.WIN_HAMMING
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    bb_gain0: '20'
    freq0: tuning
    gain0: rf_gain
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: 48e3
    type: float
  states: {}

connections:
- [analog_wfm_rcv_0, '0', low_pass_filter_1, '0']
- [blocks_multiply_const_vxx_0, '0', audio_sink_0, '0']
- [blocks_multiply_const_vxx_0, '0', qtgui_time_sink_x_0, '0']
- [low_pass_filter_0, '0', analog_wfm_rcv_0, '0']
- [low_pass_filter_1, '0', blocks_multiply_const_vxx_0, '0']
- [osmosdr_source_0, '0', low_pass_filter_0, '0']
- [osmosdr_source_0, '0', qtgui_freq_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.9.8.0
