options:
  parameters:
    generate_options: qt_gui
    id: top_block
    output_language: python
  states: {}

blocks:
- name: decim
  id: variable
  parameters:
    value: 512*4
  states: {}
- name: fft_size
  id: variable
  parameters:
    value: '512'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '2000000'
  states: {}
- name: analog_agc_xx_0
  id: analog_agc_xx
  parameters:
    gain: '1.0'
    max_gain: '65536'
    rate: '1e-4'
    reference: '1.0'
    type: complex
  states: {}
- name: analog_agc_xx_0_0
  id: analog_agc_xx
  parameters:
    gain: '1.0'
    max_gain: '65536'
    rate: '1e-4'
    reference: '1.0'
    type: complex
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: 10e3
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blks2_tcp_sink_0
  id: blks2_tcp_sink
  parameters:
    addr: 127.0.0.1
    port: '3321'
    server: 'False'
    type: float
    vlen: '1'
  states: {state: disabled}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters:
    vlen: fft_size
  states: {}
- name: blocks_complex_to_real_0
  id: blocks_complex_to_real
  parameters: {}
  states: {state: disabled}
- name: blocks_complex_to_real_0_0
  id: blocks_complex_to_real
  parameters: {}
  states: {state: disabled}
- name: blocks_complex_to_real_0_1
  id: blocks_complex_to_real
  parameters: {}
  states: {state: disabled}
- name: blocks_keep_one_in_n_0
  id: blocks_keep_one_in_n
  parameters:
    n: int(1e6)
    type: float
  states: {state: disabled}
- name: blocks_moving_average_xx_0
  id: blocks_moving_average_xx
  parameters:
    length: '1000'
    max_iter: '4000'
    scale: '1e-3'
    type: float
  states: {state: disabled}
- name: blocks_multiply_conjugate_cc_0
  id: blocks_multiply_conjugate_cc
  parameters: {}
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: fft_size
    type: complex
  states: {}
- name: blocks_udp_sink_0_0
  id: blocks_udp_sink
  parameters:
    eof: 'True'
    ipaddr: 10.10.1.7
    port: '3333'
    psize: '1472'
    type: complex
    vlen: '1'
  states: {}
- name: blocks_vector_to_stream_0
  id: blocks_vector_to_stream
  parameters:
    num_items: fft_size
    type: float
  states: {}
- name: fft_vxx_0_0_0
  id: fft_vxx
  parameters:
    fft_size: fft_size
    forward: 'False'
    nthreads: '8'
    shift: 'True'
    type: complex
    window: window.blackmanharris(fft_size)
  states: {}
- name: limesdr_sink_0
  id: limesdr_sink
  parameters:
    analog_filter_ch0: '1'
    analog_filter_ch1: '1'
    calibr_bandw_ch0: 10e6
    calibr_bandw_ch1: 10e6
    calibration_ch0: '0'
    calibration_ch1: '0'
    channel: '0'
    chip_mode: '1'
    cmix_mode_ch0: '0'
    cmix_mode_ch1: '0'
    device_type: '1'
    digital_bandw_ch0: '0'
    digital_bandw_ch1: '0'
    digital_filter_ch0: '0'
    digital_filter_ch1: '0'
    file_switch: '0'
    gain_dB_ch0: '50'
    gain_dB_ch1: '30'
    oversample: '0'
    pa_path_ch0: '1'
    pa_path_ch1: '1'
    pa_path_mini: '1'
    rf_freq: 2.45e9
    samp_rate: samp_rate
    serial: 1D3AD55F42C0AB
  states: {}
- name: limesdr_source_0
  id: limesdr_source
  parameters:
    analog_bandw_ch0: 5e6
    analog_bandw_ch1: 5e6
    analog_filter_ch0: '1'
    analog_filter_ch1: '1'
    calibr_bandw_ch0: 10e6
    calibr_bandw_ch1: 10e6
    calibration_ch0: '0'
    calibration_ch1: '0'
    channel: '0'
    chip_mode: '1'
    cmix_mode_ch0: '0'
    cmix_mode_ch1: '0'
    device_type: '1'
    digital_bandw_ch0: '0'
    digital_bandw_ch1: '0'
    digital_filter_ch0: '0'
    digital_filter_ch1: '0'
    file_switch: '0'
    gain_dB_ch0: '50'
    gain_dB_ch1: '30'
    lna_path_ch0: '2'
    lna_path_mini: '1'
    oversample: '0'
    rf_freq: 2.45e9
    samp_rate: samp_rate
    serial: 1D3AD55F42C0AB
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 1e3
    decim: decim
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 1e3
    win: firdes.WIN_HAMMING
  states: {}
- name: qtgui_number_sink_0_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_NONE
    name: Multiply Conjugate
    type: float
  states: {state: disabled}
- name: qtgui_time_raster_sink_x_0
  id: qtgui_time_raster_sink_x
  parameters:
    name: '"Mag"'
    ncols: fft_size
    nrows: '256'
    samp_rate: samp_rate
    type: float
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    label1: ''
    label2: ''
    nconnections: '2'
    size: '1024'
    srate: samp_rate
    tr_mode: qtgui.TRIG_MODE_AUTO
    type: float
  states: {state: disabled}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    label1: ''
    size: '1024'
    srate: samp_rate
    type: float
  states: {state: disabled}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate/decim
    fc: '0'
    fftsize: fft_size
    showports: 'True'
    type: complex
  states: {}

connections:
- [analog_agc_xx_0, '0', blocks_complex_to_real_0, '0']
- [analog_agc_xx_0, '0', blocks_multiply_conjugate_cc_0, '0']
- [analog_agc_xx_0_0, '0', blocks_complex_to_real_0_0, '0']
- [analog_agc_xx_0_0, '0', blocks_multiply_conjugate_cc_0, '1']
- [analog_sig_source_x_0, '0', analog_agc_xx_0, '0']
- [analog_sig_source_x_0, '0', limesdr_sink_0, '0']
- [blocks_complex_to_mag_0, '0', blocks_vector_to_stream_0, '0']
- [blocks_complex_to_real_0, '0', qtgui_time_sink_x_0, '1']
- [blocks_complex_to_real_0_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_complex_to_real_0_1, '0', blocks_moving_average_xx_0, '0']
- [blocks_keep_one_in_n_0, '0', blks2_tcp_sink_0, '0']
- [blocks_moving_average_xx_0, '0', blocks_keep_one_in_n_0, '0']
- [blocks_moving_average_xx_0, '0', qtgui_number_sink_0_0, '0']
- [blocks_moving_average_xx_0, '0', qtgui_time_sink_x_1, '0']
- [blocks_multiply_conjugate_cc_0, '0', blocks_complex_to_real_0_1, '0']
- [blocks_multiply_conjugate_cc_0, '0', low_pass_filter_0, '0']
- [blocks_stream_to_vector_0, '0', fft_vxx_0_0_0, '0']
- [blocks_vector_to_stream_0, '0', qtgui_time_raster_sink_x_0, '0']
- [fft_vxx_0_0_0, '0', blocks_complex_to_mag_0, '0']
- [limesdr_source_0, '0', analog_agc_xx_0_0, '0']
- [low_pass_filter_0, '0', blocks_stream_to_vector_0, '0']
- [low_pass_filter_0, '0', blocks_udp_sink_0_0, '0']
- [low_pass_filter_0, '0', qtgui_waterfall_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.9.8.0
