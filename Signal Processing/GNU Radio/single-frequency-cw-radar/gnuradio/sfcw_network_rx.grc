options:
  parameters:
    author: LFC
    generate_options: qt_gui
    id: top_block
    output_language: python
  states: {}

blocks:
- name: decim
  id: variable
  parameters:
    value: 512*4
  states: {}
- name: fft_size
  id: variable
  parameters:
    value: '512'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '4000000'
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    append: 'True'
    type: complex
  states: {}
- name: blocks_udp_source_0
  id: blocks_udp_source
  parameters:
    eof: 'True'
    ipaddr: 10.10.1.7
    port: '3333'
    psize: '1472'
    type: complex
    vlen: '1'
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate/decim
    fc: '0'
    fftsize: fft_size
    showports: 'True'
    type: complex
  states: {}

connections:
- [blocks_udp_source_0, '0', blocks_file_sink_0, '0']
- [blocks_udp_source_0, '0', qtgui_waterfall_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.9.8.0
